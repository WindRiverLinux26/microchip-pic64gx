require linux-yocto-mpfsoc-pic64gx.inc

KBRANCH:microchip-pic64gx  = "v6.18/standard/preempt-rt/mchp-sdk-6.18/microchip-riscv"

